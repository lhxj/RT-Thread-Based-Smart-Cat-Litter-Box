# IAR project project.ewp, settings and files
configuration Debug (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __DEBUG; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; HC32F460; __RTTHREAD__; USE_DDL_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\components\libc\posix\ipc; ..\..\..\components\finsh; ..\..\..\libcpu\arm\common; ..\..\..\libcpu\arm\cortex-m4; board\ports; ..\..\..\include; ..\..\..\components\drivers\include; ..\..\..\components\libc\posix\io\stdio; .; applications; ..\libraries\hc32_drivers; ..\libraries\hc32f460_ddl\drivers\cmsis\Include; ..\..\..\components\libc\compilers\common\extension; ..\libraries\hc32f460_ddl\drivers\cmsis\Device\HDSC\hc32f4xx\Include; ..\..\..\components\libc\compilers\common; ..\..\..\components\libc\posix\io\poll; board\config; ..\..\..\components\drivers\spi; ..\libraries\hc32f460_ddl\drivers\hc32_ll_driver\inc; board
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: rtthread.bin
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; HC32F460; __RTTHREAD__; USE_DDL_DRIVER
  group Applications
    applications/: main.c
  group AppLogic
    app_logic/: app_init.c logic.c fsm.c mqtt.c
  group Compiler
    ../../../components/libc/compilers/common/: stdlib.c time.c
    ../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group CPU
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c
  group Drivers
    board/: board.c board_config.c
    ../libraries/hc32f460_ddl/drivers/cmsis/Device/HDSC/hc32f4xx/Source/IAR/: startup_hc32f460.s
    ../libraries/hc32_drivers/: drv_gpio.c drv_irq.c drv_spi.c drv_usart.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group Libraries
    ../libraries/hc32f460_ddl/drivers/hc32_ll_driver/src/: hc32_ll_clk.c hc32_ll_icg.c hc32_ll_utility.c hc32_ll_fcg.c hc32_ll_interrupts.c hc32_ll_pwc.c hc32_ll_aos.c hc32_ll_sram.c hc32_ll.c hc32_ll_usart.c hc32_ll_efm.c hc32_ll_gpio.c hc32f460_ll_interrupts_share.c hc32_ll_rmu.c hc32_ll_spi.c hc32_ll_tmr0.c hc32_ll_dma.c
    ../libraries/hc32f460_ddl/drivers/cmsis/Device/HDSC/hc32f4xx/Source/: system_hc32f460.c
